# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F407, ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\CMSIS;..\Library\Include;..\User;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BSP;..\APPLICATION;..\BSP\sys;..\BSP\can;..\Startup;..\APPLICATION\task;..\BSP\delay;..\MODULES\led;..\BSP\fifo;..\BSP\pwm;..\BSP\spi;..\BSP\uart;..\MODULES\Emm_v5;..\MODULES\im948;..\MODULES\kalman;..\MODULES\key;..\MODULES\LobotServoController;..\MODULES\motor;..\MODULES\pid;..\MODULES\servo;..\BSP\message;..\MODULES\AS5048;..\MODULES\IM_TEST;..\MODULES\Lcd;..\APPLICATION\chasis;..\APPLICATION\gimbal;..\BSP\spi;..\APPLICATION\exchange
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c
  group Startup
    ../Startup/: startup_gd32f407.s gd32f4xx_it.c systick.c
  group Library
    ../Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group APPLICATION
    ../APPLICATION/: main.c robot_init.h
    ../APPLICATION/task/: robot_task.h robot_task_handles.h
    ../APPLICATION/chasis/: chasis.c
    ../APPLICATION/gimbal/: gimbal.c
    ../APPLICATION/exchange/: exchange.c
  group BSP
    ../BSP/sys/: sys.c
    ../BSP/delay/: delay.c
    ../BSP/can/: can.c
    ../BSP/fifo/: fifo.c
    ../BSP/uart/: uart4.c uart3.c usart.c uart1.c
    ../BSP/message/: message.c
    ../BSP/spi/: spi.c
  group MODULES
    ../MODULES/led/: led.c
    ../MODULES/key/: key.c
    ../MODULES/Emm_v5/: Emm_V5.c
    ../MODULES/im948/: im948_CMD.c
    ../MODULES/LobotServoController/: LobotServoController.c
    ../MODULES/servo/: servo.c
    ../MODULES/pid/: pid.c
    ../MODULES/motor/: motor.c encoder.c
    ../MODULES/AS5048/: AS5048.c
    ../MODULES/IM_TEST/: IM_TEST.c arm_fastmath_fallback.c
    ../MODULES/kalman/: arm_math.c kalman_filter.c
    ../MODULES/Lcd/: lcd.c
